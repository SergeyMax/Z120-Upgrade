<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\TEF6686 FM Tuner.ewp</path>
  </project>
  <batchBuild />
</workspace>
